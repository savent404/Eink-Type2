# Keil uVision project Tricolor-Eink.uvprojx, settings and files
target Tricolor-Eink (ARM-ADS)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x2000BFFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Tricolor-Eink
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --C99
  c include: ../Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Include;../Drivers/CMSIS/Device/ST/STM32F1xx/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  link misc: --diag_suppress=L6329
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_cortex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_rcc.c stm32f1xx_hal.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_dma.c stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_spi_ex.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Application/User
    ../Src/: main.c gpio.c stm32f1xx_hal_msp.c spi.c stm32f1xx_it.c EPD_W21.c nRF24L01.c nRF24L01_bsp.c
software components: CMSIS:CORE 4.1.0
